require recipes-core/images/core-image-minimal.bb
require recipes-core/images/include/zybo-agh-image.inc

export IMAGE_BASENAME = "zybo-agh-image-minimal"